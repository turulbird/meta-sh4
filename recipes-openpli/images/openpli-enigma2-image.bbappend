ENIGMA2_PLUGINS_append_sh4 += "\
	kernel-module-block2mtd libcrypto \
	"
#	enigma2-plugin-systemplugins-sparkvfdcontrol
#	enigma2-plugin-systemplugins-sh4boostercontrol

#ENIGMA2_PLUGINS_append_spark7162 += "
#	enigma2-plugin-systemplugins-uniontunertype 
#	"
