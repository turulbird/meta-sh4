OPTIONAL_PACKAGES_remove_sh4 += "\
	gdb \
	nodejs \
	smbnetfs \
	"
