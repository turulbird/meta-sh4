SRC_URI = "git://github.com/OpenVisionE2/blindscan-s2.git"
