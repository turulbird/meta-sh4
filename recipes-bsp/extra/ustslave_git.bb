DESCRIPTION = "A tool for uploading the firmware to the slave DSPs"

require audioniek-apps.inc

RDEPEND += "stslave-fw"
